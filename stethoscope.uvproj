# Keil uVision project stethoscope.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: stethoscope
  AfterMake: fromelf --bin -o build\stethoscope_LPC1768.bin build\stethoscope.axf
  c flags: Optim=1
  c define: TARGET_LPC1768,  TARGET_M3,  TARGET_CORTEX_M,  TARGET_NXP,  TARGET_LPC176X,  TARGET_MBED_LPC1768,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,  MBED_BUILD_TIMESTAMP=1432820228.74,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;USBDevice;USBDevice/USBDevice;USBDevice/USBMSD;USBDevice/USBSerial;USBDevice/USBMIDI;USBDevice/USBHID;USBDevice/USBAudio;TLV320;LCD_TextDisplay;mbed;mbed/TARGET_LPC1768;mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD;mbed/TARGET_LPC1768/TARGET_NXP;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768;SDFileSystem;SDFileSystem/FATFileSystem;SDFileSystem/FATFileSystem/ChaN;./I2SSlave;./Adafruit_GFX
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/system_LPC17xx.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/startup_LPC17xx.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    ./: main.cpp
    ./: AverageFilter.cpp GlobalResource.cpp SoundBuffer.cpp FIRFilter.cpp
  group USB
    USBDevice/USBAudio/: USBAudio.cpp
    USBDevice/USBHID/: USBHID.cpp USBMouse.cpp USBKeyboard.cpp USBMouseKeyboard.cpp
    USBDevice/USBMIDI/: USBMIDI.cpp
    USBDevice/USBDevice/: USBHAL_KL25Z.cpp USBDevice.cpp USBHAL_LPC11U.cpp USBHAL_LPC40.cpp USBHAL_Maxim.cpp USBHAL_STM32F4.cpp USBHAL_LPC17.cpp USBHAL_RZ_A1H.cpp
    USBDevice/USBSerial/: USBSerial.cpp USBCDC.cpp
    USBDevice/USBMSD/: USBMSD.cpp
  group LCD
    ./LCD_TextDisplay/: LCD_main.cpp
    LCD_TextDisplay/: LCD.cpp
  group SD
    SDFileSystem/FATFileSystem/ChaN/: ccsbcs.cpp ff.cpp diskio.cpp
    SDFileSystem/FATFileSystem/: FATFileHandle.cpp FATDirHandle.cpp FATFileSystem.cpp
    SDFileSystem/: SDFileSystem.cpp
  group Audio
    ./I2SSlave/: I2SSlave.cpp
    ./TLV320/: TLV320.cpp
  group Screen
    ./Adafruit_GFX/: Adafruit_GFX.cpp Adafruit_SSD1306.cpp
